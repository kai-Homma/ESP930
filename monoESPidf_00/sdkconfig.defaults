## monoESPidf_00/sdkconfig.defaults
```kconfig
# CONFIG_ADC_CONTINUOUS_FORCE_USE_ADC2_ON_C3_S3 is not set
CONFIG_ADC_CONTINUOUS_TYPE2_DRIVER=y
```
